# Keil uVision project iSO-STM32.uvproj, settings and files
target Template (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Template +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\TMC_API\helpers;..\..\User\TMC_API\tmc5130;..\..\User\TMC_API;..\..\User\TMC_EvalSystem\boards;..\..\User\TMC_EvalSystem\hal;..\..\User\TMC_EvalSystem\tmc;..\..\User\TMC_EvalSystem
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group TMC_API
    ../../User/TMC_API/helpers/: CRC.c Debug.c
    ../../User/TMC_API/tmc5130/: TMC5130.c
  group TMC_EvalSystem
    ../../User/TMC_EvalSystem/boards/: Board.c TMC5130_eval.c TMCDriver.c TMCMotionController.c
    ../../User/TMC_EvalSystem/hal/: ADCs.c HAL.c IOMap.c IOs.c LEDs.c RS232.c SPI.c SysTick.c Timer.c UART.c keys.c
    ../../User/TMC_EvalSystem/tmc/: BoardAssignment.c IdDetection_Startrampe.c IdEeprom.c StepDir.c TMCL.c VitalSignsMonitor.c
